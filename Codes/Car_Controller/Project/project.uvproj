# Keil uVision project project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: project +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\STM32F10x_StdPeriph_Driver\inc;..\Platform;..\User;..\Motor_Controller;..\Han_Lib
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group StartUp
    ./: startup_stm32f10x_hd.s
  group STM32F1Lib
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c
  group USER
    ../User/: main.c
  group Platform
    ../platform/: port.c
    ../Platform/: stm32f10x_it.c system_stm32f10x.c
  group Motor_Controller
    ../Motor_Controller/: driver.c io.c
  group Han_Lib
    ../Han_Lib/: HanLib.c HanAlgorithm.c
